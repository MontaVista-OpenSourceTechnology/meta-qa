QATEST_DIR ?= "/opt/qa"
QATEST_BIN_DIR ?= "${QATEST_DIR}/bin"
QATEST_RESULTS_DIR ?= "${QATEST_DIR}/results"
QATEST_SUITES_DIR ?= "${QATEST_DIR}/testsuites"
DIRFILES = "1"
