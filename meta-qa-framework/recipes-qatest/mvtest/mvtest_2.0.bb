# 
# Copyright 2017-2020 MontaVista LLC.
#
SUMMARY = "An open-source automated test suite based on pytest framework to perform a full-fledged QA"
include mvtest-2.0.inc
include mvtest.inc
