inherit pypi setuptools

LICENSE = "MPL-2.0"
PYPI_PACKAGE = "pytest-html"

SRC_URI[md5sum] = "47801895fefa522b2d1cfa0cebdba6d6"
SRC_URI[sha256sum] = "9a1e9d90cb3b32b23d3e47b71df798cd82c1764bf72b9a428541d32aa665c0bf"

LIC_FILES_CHKSUM = "file://LICENSE;md5=5d425c8f3157dbf212db2ec53d9e5132"

DEPENDS += "python-setuptools-scm-native"
